## src/drone_firmware/Kconfig
```kconfig
menuconfig MODULES_sprayer
    bool "sprayer"
    default y
    ---help---
        Enable support for sprayer
```
